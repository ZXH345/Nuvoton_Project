# Keil uVision project Nuvoton_Project.uvproj, settings and files
target Nuvoton_Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: NUC029LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Nuvoton_Project +hex
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ./CMSIS/Src/: startup_M051Series.s
  group User
    ./User/: Main.s
